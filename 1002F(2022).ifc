Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-08-22T09:36:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 22 09:36:31 2022 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\{1F538D70-5AA7-49CC-9FBD-84709A596DF3}\ifc * Database version: 5507 * Database creation date: Mon Aug 22 09:36:29 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 22 09:36:30 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 22 09:36:30 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowController: 1002F High washbasin faucet, 1002F(2022):1002F High washbasin faucet:33495
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - FaucetNominalDepth: 188.451 mm; FaucetNominalHeight: 281.224 mm; FaucetNominalWidth: 50 mm; HandShowerNominalDepth: 68.2057 mm; HandShowerNominalHeight: 285.859 mm; HandShowerNominalWidth: 45.9 mm; InletConnectionSize: 10 mm
Type - General - Author: BIMStone; BIMObjectName: 1002F(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Washbasin faucet with Bidetta hand shower; Revision: n/a; Uniclass2: Pr_40_30_96_97; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 01/07/2022
Type - Green Building Properties - Approval KIWA SE Type Approval: 1490; EAN Number: 6414150100406; EN Standard: EN 817; LVI Number: 6110393; Noise Class: I (ISO 3822); NRF Number: 4205442; RSK Number: 8275002; Sales Package dimensions (LxWxH): 754 x 334 x 63; STF Certificate: EUFI-RTH-00090-17; URL Declaration of Conformity: http://static.oras.com/DoC/1002F; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/1002F; URL REACH: http://static.oras.com/doc/reach; URL STF: http://static.oras.com/STF/1002F; VVS Number: 703892604
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/1002F; 3D View: https://static.oras.com/3D/1002F; Catalog Drawing URL: http://static.oras.com/catdrw/1002F; Dimension Drawing URL: http://static.oras.com/dimdrw/1002F; FDV Document URL: http://www.oras.com/datasheet/1002F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1002F; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/1002F; Interactive AR View URL: https://static.oras.com/AR/1002F; Long Marketing: High washbasin faucet with Bidetta hand shower. Fixed spout and aerator. Shower hose 1.75 m, wall bracket. There are also in-built limitation options for water temperature and maximum flow-rate. F = with flexible pipes; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/1002F; Model: 1002F High washbasin faucet; Name_en: 1002F High washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1002F; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1002F; Product URL: http://static.oras.com/1002F; Technical DataSheet URL: http://www.oras.com/datasheet/1002F/en; Type Name: 1002F High washbasin faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Aerator: Standard aerator; Backflow Prevention EN1717: HC; Connection: Flexible inlet pipes; Connection Size: G3/4; Excluded Items: Without pop-up waste; Flow Rate At 300kPa: 0.00459091 m3/s; Hand Shower: Bidetta hand shower; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Pressure Loss With Flow 01ls: 180000 Pa; Shower Parts: Shower holder;Shower hose (1750 mm); Shower Spray Number: 1 shower spray; Spout Projection: 150 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1002F(2022); Features: Single-lever;Bidetta; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1002F; Name: 1002F High washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x144x147 mm / Hand shower: 46x64x286 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.111624 m2; Volume: 0.00342192 m3
Identity Data - Mark: 13
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1002F(2022): 1002F High washbasin faucet; Family and Type: 1002F(2022): 1002F High washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1002F(2022): 1002F High washbasin faucet; Type Id: 1002F(2022): 1002F High washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
